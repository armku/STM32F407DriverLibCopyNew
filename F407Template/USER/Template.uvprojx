# Keil uVision project Template.uvprojx, settings and files
target Template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\libraries\ToolBox\Buffer;..\libraries\System;..\libraries\System\Interrupt;..\libraries\System\TaskManager;..\libraries\OnChip\SerialPort;..\libraries\OffChip;..\libraries\OnChip\IIC;..\libraries\OnChip\ADC;..\libraries\OnChip\InputCapture;..\libraries\OnChip\Timer;..\libraries\OnChip\PWM;..\libraries\OffChip\InertialSensor;..\libraries\ToolBox\Math;..\libraries\OnChip\SPI;..\libraries\OnChip\GPIO;..\libraries\OffChip\Print;..\libraries\OffChip\W25QXX;..\libraries\OffChip\GPRS;..\SYSTEM\SoftwareI2C;..\libraries\OffChip\ESP8266;..\libraries\OffChip\SHT2X;..\libraries\OffChip\Monitor;..\libraries\ToolBox\GidLink;..\libraries\ToolBox\CRC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.cpp App.cpp
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ./: system_stm32f4xx.cpp stm32f4xx_it.cpp
    ../libraries/System/Interrupt/: Interrupt.cpp
    ../libraries/System/TaskManager/: TaskManager.cpp
    ../SYSTEM/sys/: sys.cpp
    ../libraries/System/: Configuration.h
    ../libraries/ToolBox/Util/: util.cpp
  group README
    ../README/: README.txt
  group OnChip
    ../libraries/OnChip/ADC/: ADC.cpp
    ../libraries/OnChip/SPI/: SPI.cpp
    ../libraries/OnChip/Timer/: Timer.cpp
    ../libraries/OnChip/SerialPort/: USART.cpp
    ../SYSTEM/SoftwareI2C/: SoftwareI2C.cpp
    ../libraries/OnChip/GPIO/: GPIO.cpp
  group OffChip
    ../libraries/OffChip/Print/: DPPrint.cpp
    ../libraries/OffChip/W25QXX/: W25QXX.cpp
    ../libraries/OffChip/GPRS/: GPRS.cpp
    ../libraries/OffChip/ESP8266/: esp8266.cpp Socket_esp8266.cpp
    ../libraries/OffChip/Monitor/: Monitor.cpp
    ../libraries/OffChip/SHT2X/: SHT2X.cpp
  group ToolBox
    ../libraries/ToolBox/GidLink/: GidLink.cpp
    ../libraries/ToolBox/CRC/: CRC.cpp
software components: CMSIS:CORE 5.0.0
